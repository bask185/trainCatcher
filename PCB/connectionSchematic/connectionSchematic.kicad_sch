File: PCB/connectionSchematic/connectionSchematic.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: added more pictures
Other:
- note added: "5V"
- note added: "GND"
